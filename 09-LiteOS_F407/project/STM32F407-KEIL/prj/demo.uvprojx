# Keil uVision project demo.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\config;..\..\..\kernel\cmsis;..\..\..\kernel\link\keil;..\..\..\kernel\cpu\arm\cortex-m4;..\..\..\example\include;..\..\..\platform\LOS_EXPAND_XXX\drivers\Inc;..\..\..\platform\LOS_EXPAND_XXX\STM32F4xx_HAL_Driver\Inc;..\..\..\platform\LOS_EXPAND_XXX\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\platform\LOS_EXPAND_XXX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../../kernel/base/misc/: los_misc.c
  group config
    ../../../kernel/config/: los_config.c
  group cpu/m4
    ../../../kernel/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group cmsis
    ../../../kernel/cmsis/: cmsis_liteos.c
  group platform/expend_xxx
    ../../../platform/LOS_EXPAND_XXX/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group user
    ../../../user/: main.c
  group lib
    ../../../platform/LOS_EXPAND_XXX/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c
    ../../../platform/LOS_EXPAND_XXX/drivers/Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c
  group example
    ../../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_fs.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.6.0
